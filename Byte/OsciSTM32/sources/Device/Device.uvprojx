# Keil uVision project Device.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F746IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F746I Configuration
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,__STRICT_ANSI__
  c misc: --cpp
  c include: ..\common\stm32CubeF7\Drivers\STM32F7xx_HAL_Driver\Inc;.\src\Hardware\HAL;..\common\stm32CubeF7\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\common\stm32CubeF7\Drivers\CMSIS\Include;..\common;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group CMSIS
    ../common/stm32CubeF7/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f746xx.s
    ../common/stm32CubeF7/Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group HAL
    ../common/stm32CubeF7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_uart.c
    ../common/stm32CubeF7/Drivers/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal_uart.h
  group src
    Src/: main.cpp
  group Display
    ./src/Display/: Display.cpp Display.h Primitives.cpp Primitives.h Colors.cpp Colors.h
  group Display/Font
    ./src/Display/Font/: Font.cpp Font.h font8.cpp font12.cpp font16.cpp font20.cpp font24.cpp
  group Hardware
    ./src/Hardware/: Timer.cpp Timer.h
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.cpp HAL.h HAL_FMC.cpp HAL_GPIO.cpp HAL_I2C.cpp HAL_IT.cpp HAL_LTDC.cpp HAL_UART1.cpp stm32f7xx_hal_conf.h stm32746g_sdram.cpp stm32746g_sdram.h HAL_SDRAM.cpp
  group Hardware/Touch
    ./src/Hardware/Touch/: Touch.cpp Touch.h TS_I2C.cpp TS_I2C.h
